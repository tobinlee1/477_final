<?xml version="1.0"?>
<setupdb version="8">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Oct 13 23:54:47 2026</timestamp>
			<uuid>{44f03ee2-2a0b-49e0-a3ed-e83d0f88faad}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/tobinlee@vlab.usc.edu/work_gpdk045/lab2/XOR_test/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/home/tobinlee@vlab.usc.edu/simulation/lab2/XOR_test/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>/home/tobinlee@vlab.usc.edu/simulation/lab2/XOR_test/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
	</history>
</setupdb>
